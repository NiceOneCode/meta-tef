FILESEXTRAPATHS_prepend := "${THISDIR}/eudev:"
PR = "r10"

#INITSCRIPT_PARAMS_eudev = "start 08 S ."
