DESCRIPTION = "DMG Diner image base for geam6ul"

include n1c-tef-gx6ul.inc

export IMAGE_BASENAME = "dmg-filesystem-primary"
export IMAGE_NAME     =  "${MACHINE}-filesystem-primary"
